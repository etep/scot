* FILE: dec8_256.sp

******************* default header for EE371 Optimization*********
* setting process file
*
* * generate .tr0 file
 .options post
*
* *********************** end header ******************************
*

* SPICE netlist for "dec8_256" (generated by MMI_SUE4.4.1)

.SUBCKT t_2nand egress in1 in2 WP=0.5 WN=0.3 Din1RF=0 Din1FR=0 Din2RF=0
+ Din2FR=0
M_1 egress in1 int1 gnd nmos W=WN L=0.1 GEO=0
M_2 int1 in2 gnd gnd nmos W=WN L=0.1 GEO=0
M_3 Vdd in1 egress Vdd pmos W=WP L=0.1 GEO=0
M_4 Vdd in2 egress Vdd pmos W=WP L=0.1 GEO=0
.ENDS	$ t_2nand

.SUBCKT dec2_4 in[0] in[1] in_b[0] in_b[1] out[0] out[1] out[2] out[3]
Xt_2nand_1 out[0] in[0] in[1] t_2nand
Xt_2nand_2 out[1] in[0] in_b[1] t_2nand
Xt_2nand_3 out[2] in_b[0] in[1] t_2nand
Xt_2nand_4 out[3] in_b[0] in_b[1] t_2nand
.ENDS	$ dec2_4

.SUBCKT t_inv egress in WP=0.5 WN=0.2 DinRF=0 DinFR=0
M_1 vdd in egress vdd pmos W=WP L=0.1 GEO=0
M_2 egress in gnd gnd nmos W=WN L=0.1 GEO=0
*localcnst:  WP^-1 WN < 1;
.ENDS	$ t_inv

.SUBCKT dec_16_out inA inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6]
+ inB[7] inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15]
+ out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9]
+ out[10] out[11] out[12] out[13] out[14] out[15]
Xt_2nand_1 mynet_1 inA inB[0] t_2nand
Xt_inv_1 out[0] mynet_1 t_inv
Xt_2nand_2 mynet_2 inA inB[1] t_2nand
Xt_inv_2 out[1] mynet_2 t_inv
Xt_2nand_3 mynet_3 inA inB[2] t_2nand
Xt_inv_3 out[2] mynet_3 t_inv
Xt_2nand_4 mynet_4 inA inB[3] t_2nand
Xt_inv_4 out[3] mynet_4 t_inv
Xt_2nand_5 mynet_5 inA inB[4] t_2nand
Xt_inv_5 out[4] mynet_5 t_inv
Xt_2nand_6 mynet_6 inA inB[5] t_2nand
Xt_inv_6 out[5] mynet_6 t_inv
Xt_2nand_7 mynet_7 inA inB[6] t_2nand
Xt_inv_7 out[6] mynet_7 t_inv
Xt_2nand_8 mynet_8 inA inB[7] t_2nand
Xt_inv_8 out[7] mynet_8 t_inv
Xt_2nand_9 mynet_9 inA inB[8] t_2nand
Xt_inv_9 out[8] mynet_9 t_inv
Xt_2nand_10 mynet_10 inA inB[9] t_2nand
Xt_inv_10 out[9] mynet_10 t_inv
Xt_2nand_11 mynet_11 inA inB[10] t_2nand
Xt_inv_11 out[10] mynet_11 t_inv
Xt_2nand_12 mynet_12 inA inB[11] t_2nand
Xt_inv_12 out[11] mynet_12 t_inv
Xt_2nand_13 mynet_13 inA inB[12] t_2nand
Xt_inv_13 out[12] mynet_13 t_inv
Xt_2nand_14 mynet_14 inA inB[13] t_2nand
Xt_inv_14 out[13] mynet_14 t_inv
Xt_2nand_15 mynet_15 inA inB[14] t_2nand
Xt_inv_15 out[14] mynet_15 t_inv
Xt_2nand_16 mynet_16 inA inB[15] t_2nand
Xt_inv_16 out[15] mynet_16 t_inv
.ENDS	$ dec_16_out

.SUBCKT dec_256_out inA[0] inA[1] inA[2] inA[3] inA[4] inA[5] inA[6] inA[7]
+ inA[8] inA[9] inA[10] inA[11] inA[12] inA[13] inA[14] inA[15] inB[0]
+ inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7] inB[8] inB[9] inB[10]
+ inB[11] inB[12] inB[13] inB[14] inB[15] out[0] out[1] out[2] out[3]
+ out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11] out[12] out[13]
+ out[14] out[15] out[16] out[17] out[18] out[19] out[20] out[21] out[22]
+ out[23] out[24] out[25] out[26] out[27] out[28] out[29] out[30] out[31]
+ out[32] out[33] out[34] out[35] out[36] out[37] out[38] out[39] out[40]
+ out[41] out[42] out[43] out[44] out[45] out[46] out[47] out[48] out[49]
+ out[50] out[51] out[52] out[53] out[54] out[55] out[56] out[57] out[58]
+ out[59] out[60] out[61] out[62] out[63] out[64] out[65] out[66] out[67]
+ out[68] out[69] out[70] out[71] out[72] out[73] out[74] out[75] out[76]
+ out[77] out[78] out[79] out[80] out[81] out[82] out[83] out[84] out[85]
+ out[86] out[87] out[88] out[89] out[90] out[91] out[92] out[93] out[94]
+ out[95] out[96] out[97] out[98] out[99] out[100] out[101] out[102]
+ out[103] out[104] out[105] out[106] out[107] out[108] out[109] out[110]
+ out[111] out[112] out[113] out[114] out[115] out[116] out[117] out[118]
+ out[119] out[120] out[121] out[122] out[123] out[124] out[125] out[126]
+ out[127] out[128] out[129] out[130] out[131] out[132] out[133] out[134]
+ out[135] out[136] out[137] out[138] out[139] out[140] out[141] out[142]
+ out[143] out[144] out[145] out[146] out[147] out[148] out[149] out[150]
+ out[151] out[152] out[153] out[154] out[155] out[156] out[157] out[158]
+ out[159] out[160] out[161] out[162] out[163] out[164] out[165] out[166]
+ out[167] out[168] out[169] out[170] out[171] out[172] out[173] out[174]
+ out[175] out[176] out[177] out[178] out[179] out[180] out[181] out[182]
+ out[183] out[184] out[185] out[186] out[187] out[188] out[189] out[190]
+ out[191] out[192] out[193] out[194] out[195] out[196] out[197] out[198]
+ out[199] out[200] out[201] out[202] out[203] out[204] out[205] out[206]
+ out[207] out[208] out[209] out[210] out[211] out[212] out[213] out[214]
+ out[215] out[216] out[217] out[218] out[219] out[220] out[221] out[222]
+ out[223] out[224] out[225] out[226] out[227] out[228] out[229] out[230]
+ out[231] out[232] out[233] out[234] out[235] out[236] out[237] out[238]
+ out[239] out[240] out[241] out[242] out[243] out[244] out[245] out[246]
+ out[247] out[248] out[249] out[250] out[251] out[252] out[253] out[254]
+ out[255] CwPredec=52
Xdec_16_o_1 inA[4] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[64]
+ out[65] out[66] out[67] out[68] out[69] out[70] out[71] out[72] out[73]
+ out[74] out[75] out[76] out[77] out[78] out[79] dec_16_out
Xdec_16_o_2 inA[5] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[80]
+ out[81] out[82] out[83] out[84] out[85] out[86] out[87] out[88] out[89]
+ out[90] out[91] out[92] out[93] out[94] out[95] dec_16_out
Xdec_16_o_3 inA[6] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[96]
+ out[97] out[98] out[99] out[100] out[101] out[102] out[103] out[104]
+ out[105] out[106] out[107] out[108] out[109] out[110] out[111] dec_16_out
+
Xdec_16_o_4 inA[7] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[112]
+ out[113] out[114] out[115] out[116] out[117] out[118] out[119] out[120]
+ out[121] out[122] out[123] out[124] out[125] out[126] out[127] dec_16_out
+
Xdec_16_o_5 inA[8] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[128]
+ out[129] out[130] out[131] out[132] out[133] out[134] out[135] out[136]
+ out[137] out[138] out[139] out[140] out[141] out[142] out[143] dec_16_out
+
Xdec_16_o_6 inA[9] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[144]
+ out[145] out[146] out[147] out[148] out[149] out[150] out[151] out[152]
+ out[153] out[154] out[155] out[156] out[157] out[158] out[159] dec_16_out
+
Xdec_16_o_7 inA[10] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[160]
+ out[161] out[162] out[163] out[164] out[165] out[166] out[167] out[168]
+ out[169] out[170] out[171] out[172] out[173] out[174] out[175] dec_16_out
+
Xdec_16_o_8 inA[11] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[176]
+ out[177] out[178] out[179] out[180] out[181] out[182] out[183] out[184]
+ out[185] out[186] out[187] out[188] out[189] out[190] out[191] dec_16_out
+
Xdec_16_o_9 inA[12] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[192]
+ out[193] out[194] out[195] out[196] out[197] out[198] out[199] out[200]
+ out[201] out[202] out[203] out[204] out[205] out[206] out[207] dec_16_out
+
Xdec_16_o_10 inA[13] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6]
+ inB[7] inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15]
+ out[208] out[209] out[210] out[211] out[212] out[213] out[214] out[215]
+ out[216] out[217] out[218] out[219] out[220] out[221] out[222] out[223]
+ dec_16_out
Xdec_16_o_11 inA[14] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6]
+ inB[7] inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15]
+ out[224] out[225] out[226] out[227] out[228] out[229] out[230] out[231]
+ out[232] out[233] out[234] out[235] out[236] out[237] out[238] out[239]
+ dec_16_out
Xdec_16_o_12 inA[15] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6]
+ inB[7] inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15]
+ out[240] out[241] out[242] out[243] out[244] out[245] out[246] out[247]
+ out[248] out[249] out[250] out[251] out[252] out[253] out[254] out[255]
+ dec_16_out
Xdec_16_o_13 inA[0] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[0]
+ out[1] out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9] out[10]
+ out[11] out[12] out[13] out[14] out[15] dec_16_out
Xdec_16_o_14 inA[1] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[16]
+ out[17] out[18] out[19] out[20] out[21] out[22] out[23] out[24] out[25]
+ out[26] out[27] out[28] out[29] out[30] out[31] dec_16_out
Xdec_16_o_15 inA[2] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[32]
+ out[33] out[34] out[35] out[36] out[37] out[38] out[39] out[40] out[41]
+ out[42] out[43] out[44] out[45] out[46] out[47] dec_16_out
Xdec_16_o_16 inA[3] inB[0] inB[1] inB[2] inB[3] inB[4] inB[5] inB[6] inB[7]
+ inB[8] inB[9] inB[10] inB[11] inB[12] inB[13] inB[14] inB[15] out[48]
+ out[49] out[50] out[51] out[52] out[53] out[54] out[55] out[56] out[57]
+ out[58] out[59] out[60] out[61] out[62] out[63] dec_16_out
C_1 gnd inA[0] CwPredec
C_2 gnd inA[1] CwPredec
C_3 gnd inA[2] CwPredec
C_4 gnd inA[3] CwPredec
C_5 gnd inA[4] CwPredec
C_6 gnd inA[5] CwPredec
C_7 gnd inA[6] CwPredec
C_8 gnd inA[7] CwPredec
C_9 gnd inA[15] CwPredec
C_10 gnd inA[14] CwPredec
C_11 gnd inA[13] CwPredec
C_12 gnd inA[12] CwPredec
C_13 gnd inA[11] CwPredec
C_14 gnd inA[10] CwPredec
C_15 gnd inA[9] CwPredec
C_16 gnd inA[8] CwPredec
C_17 gnd inB[15] CwPredec
C_18 gnd inB[14] CwPredec
C_19 gnd inB[13] CwPredec
C_20 gnd inB[12] CwPredec
C_21 gnd inB[11] CwPredec
C_22 gnd inB[10] CwPredec
C_23 gnd inB[9] CwPredec
C_24 gnd inB[8] CwPredec
C_25 gnd inB[7] CwPredec
C_26 gnd inB[5] CwPredec
C_27 gnd inB[4] CwPredec
C_28 gnd inB[3] CwPredec
C_29 gnd inB[2] CwPredec
C_30 gnd inB[1] CwPredec
C_31 gnd inB[0] CwPredec
C_32 gnd inB[6] CwPredec
.ENDS	$ dec_256_out

.SUBCKT inv_4 in[0] in[1] in[2] in[3] out[0] out[1] out[2] out[3]
Xt_inv_1 out[0] in[0] t_inv
Xt_inv_2 out[1] in[1] t_inv
Xt_inv_3 out[2] in[2] t_inv
Xt_inv_4 out[3] in[3] t_inv
.ENDS	$ inv_4

.SUBCKT inv3_8_predec in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7]
+ out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7]
Xt_inv_1 mynet_16 mynet_1 t_inv
Xt_inv_2 out[0] mynet_16 t_inv
Xt_inv_3 mynet_15 mynet_2 t_inv
Xt_inv_4 out[1] mynet_15 t_inv
Xt_inv_5 mynet_14 mynet_3 t_inv
Xt_inv_6 out[2] mynet_14 t_inv
Xt_inv_7 mynet_13 mynet_4 t_inv
Xt_inv_8 out[3] mynet_13 t_inv
Xt_inv_9 mynet_12 mynet_5 t_inv
Xt_inv_10 out[4] mynet_12 t_inv
Xt_inv_11 mynet_11 mynet_6 t_inv
Xt_inv_12 out[5] mynet_11 t_inv
Xt_inv_13 mynet_10 mynet_7 t_inv
Xt_inv_14 out[6] mynet_10 t_inv
Xt_inv_15 mynet_9 mynet_8 t_inv
Xt_inv_16 out[7] mynet_9 t_inv
Xt_inv mynet_1 in[0] t_inv
Xt_inv_17 mynet_2 in[1] t_inv
Xt_inv_18 mynet_3 in[2] t_inv
Xt_inv_19 mynet_4 in[3] t_inv
Xt_inv_20 mynet_5 in[4] t_inv
Xt_inv_21 mynet_6 in[5] t_inv
Xt_inv_22 mynet_7 in[6] t_inv
Xt_inv_23 mynet_8 in[7] t_inv
.ENDS	$ inv3_8_predec

.SUBCKT inv3_16_predec in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7]
+ in[8] in[9] in[10] in[11] in[12] in[13] in[14] in[15] out[0] out[1]
+ out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11]
+ out[12] out[13] out[14] out[15]
Xinv3_8_p_1 in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7] out[0] out[1]
+ out[2] out[3] out[4] out[5] out[6] out[7] inv3_8_predec
Xinv3_8_p_2 in[8] in[9] in[10] in[11] in[12] in[13] in[14] in[15] out[8]
+ out[9] out[10] out[11] out[12] out[13] out[14] out[15] inv3_8_predec
.ENDS	$ inv3_16_predec

.SUBCKT t_3nand egress in1 in2 in3 WP=1 WN=1.5
MtNMOS_1 int1 in2 net_1 gnd nmos W=WN L=0.1 GEO=0
MtNMOS_2 egress in1 int1 gnd nmos W=WN L=0.1 GEO=0
MtPMOS_su_2 Vdd in1 egress Vdd pmos W=WP L=0.1 GEO=0
MtPMOS_su_3 Vdd in2 egress Vdd pmos W=WP L=0.1 GEO=0
MtPMOS_su_4 Vdd in3 egress Vdd pmos W=WP L=0.1 GEO=0
MtNMOS_4 net_1 in3 gnd gnd nmos W=WN L=0.1 GEO=0
.ENDS	$ t_3nand

.SUBCKT dec4_16 clk inA[0] inA[1] inA[2] inA[3] inB[0] inB[1] inB[2] inB[3]
+ out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9]
+ out[10] out[11] out[12] out[13] out[14] out[15]
C_1 gnd inA[3] 5
C_2 gnd inA[2] 5
C_3 gnd inA[1] 5
C_4 gnd inA[0] 5
C_5 gnd inB[0] 5
C_6 gnd inB[1] 5
C_7 gnd inB[2] 5
C_8 gnd inB[3] 5
Xt_3nand out[1] inA[0] clk inB[1] t_3nand
Xt_3nand_1 out[2] inA[0] clk inB[2] t_3nand
Xt_3nand_2 out[3] inA[0] clk inB[3] t_3nand
Xt_3nand_3 out[4] inA[1] clk inB[0] t_3nand
Xt_3nand_4 out[5] inA[1] clk inB[1] t_3nand
Xt_3nand_5 out[6] inA[1] clk inB[2] t_3nand
Xt_3nand_6 out[7] inA[1] clk inB[3] t_3nand
Xt_3nand_7 out[8] inA[2] clk inB[0] t_3nand
Xt_3nand_8 out[9] inA[2] clk inB[1] t_3nand
Xt_3nand_9 out[10] inA[2] clk inB[2] t_3nand
Xt_3nand_10 out[11] inA[2] clk inB[3] t_3nand
Xt_3nand_11 out[12] inA[3] clk inB[0] t_3nand
Xt_3nand_12 out[13] inA[3] clk inB[1] t_3nand
Xt_3nand_13 out[14] inA[3] clk inB[2] t_3nand
Xt_3nand_14 out[15] inA[3] clk inB[3] t_3nand
Xt_3nand_15 out[0] inA[0] clk inB[0] t_3nand
.ENDS	$ dec4_16

* start main CELL dec8_256
* .SUBCKT dec8_256 clk in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7]
*+ in_b[0] in_b[1] in_b[2] in_b[3] in_b[4] in_b[5] in_b[6] in_b[7] wl[0]
*+ wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11]
*+ wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21]
*+ wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31]
*+ wl[32] wl[33] wl[34] wl[35] wl[36] wl[37] wl[38] wl[39] wl[40] wl[41]
*+ wl[42] wl[43] wl[44] wl[45] wl[46] wl[47] wl[48] wl[49] wl[50] wl[51]
*+ wl[52] wl[53] wl[54] wl[55] wl[56] wl[57] wl[58] wl[59] wl[60] wl[61]
*+ wl[62] wl[63] wl[64] wl[65] wl[66] wl[67] wl[68] wl[69] wl[70] wl[71]
*+ wl[72] wl[73] wl[74] wl[75] wl[76] wl[77] wl[78] wl[79] wl[80] wl[81]
*+ wl[82] wl[83] wl[84] wl[85] wl[86] wl[87] wl[88] wl[89] wl[90] wl[91]
*+ wl[92] wl[93] wl[94] wl[95] wl[96] wl[97] wl[98] wl[99] wl[100] wl[101]
*+ wl[102] wl[103] wl[104] wl[105] wl[106] wl[107] wl[108] wl[109] wl[110]
*+ wl[111] wl[112] wl[113] wl[114] wl[115] wl[116] wl[117] wl[118] wl[119]
*+ wl[120] wl[121] wl[122] wl[123] wl[124] wl[125] wl[126] wl[127] wl[128]
*+ wl[129] wl[130] wl[131] wl[132] wl[133] wl[134] wl[135] wl[136] wl[137]
*+ wl[138] wl[139] wl[140] wl[141] wl[142] wl[143] wl[144] wl[145] wl[146]
*+ wl[147] wl[148] wl[149] wl[150] wl[151] wl[152] wl[153] wl[154] wl[155]
*+ wl[156] wl[157] wl[158] wl[159] wl[160] wl[161] wl[162] wl[163] wl[164]
*+ wl[165] wl[166] wl[167] wl[168] wl[169] wl[170] wl[171] wl[172] wl[173]
*+ wl[174] wl[175] wl[176] wl[177] wl[178] wl[179] wl[180] wl[181] wl[182]
*+ wl[183] wl[184] wl[185] wl[186] wl[187] wl[188] wl[189] wl[190] wl[191]
*+ wl[192] wl[193] wl[194] wl[195] wl[196] wl[197] wl[198] wl[199] wl[200]
*+ wl[201] wl[202] wl[203] wl[204] wl[205] wl[206] wl[207] wl[208] wl[209]
*+ wl[210] wl[211] wl[212] wl[213] wl[214] wl[215] wl[216] wl[217] wl[218]
*+ wl[219] wl[220] wl[221] wl[222] wl[223] wl[224] wl[225] wl[226] wl[227]
*+ wl[228] wl[229] wl[230] wl[231] wl[232] wl[233] wl[234] wl[235] wl[236]
*+ wl[237] wl[238] wl[239] wl[240] wl[241] wl[242] wl[243] wl[244] wl[245]
*+ wl[246] wl[247] wl[248] wl[249] wl[250] wl[251] wl[252] wl[253] wl[254]
*+ wl[255]
Xd24_4 in[6] in[7] in_b[6] in_b[7] dec4_b[12] dec4_b[13] dec4_b[14]
+ dec4_b[15] dec2_4
Xd24_3 in[4] in[5] in_b[4] in_b[5] dec4_b[8] dec4_b[9] dec4_b[10]
+ dec4_b[11] dec2_4
Xd24_1 in[0] in[1] in_b[0] in_b[1] dec4_b[0] dec4_b[1] dec4_b[2] dec4_b[3]
+ dec2_4
Xd24_2 in[2] in[3] in_b[2] in_b[3] dec4_b[4] dec4_b[5] dec4_b[6] dec4_b[7]
+ dec2_4
Xd16_256 predecA[0] predecA[1] predecA[2] predecA[3] predecA[4] predecA[5]
+ predecA[6] predecA[7] predecA[8] predecA[9] predecA[10] predecA[11]
+ predecA[12] predecA[13] predecA[14] predecA[15] predecB[0] predecB[1]
+ predecB[2] predecB[3] predecB[4] predecB[5] predecB[6] predecB[7]
+ predecB[8] predecB[9] predecB[10] predecB[11] predecB[12] predecB[13]
+ predecB[14] predecB[15] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7]
+ wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17]
+ wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27]
+ wl[28] wl[29] wl[30] wl[31] wl[32] wl[33] wl[34] wl[35] wl[36] wl[37]
+ wl[38] wl[39] wl[40] wl[41] wl[42] wl[43] wl[44] wl[45] wl[46] wl[47]
+ wl[48] wl[49] wl[50] wl[51] wl[52] wl[53] wl[54] wl[55] wl[56] wl[57]
+ wl[58] wl[59] wl[60] wl[61] wl[62] wl[63] wl[64] wl[65] wl[66] wl[67]
+ wl[68] wl[69] wl[70] wl[71] wl[72] wl[73] wl[74] wl[75] wl[76] wl[77]
+ wl[78] wl[79] wl[80] wl[81] wl[82] wl[83] wl[84] wl[85] wl[86] wl[87]
+ wl[88] wl[89] wl[90] wl[91] wl[92] wl[93] wl[94] wl[95] wl[96] wl[97]
+ wl[98] wl[99] wl[100] wl[101] wl[102] wl[103] wl[104] wl[105] wl[106]
+ wl[107] wl[108] wl[109] wl[110] wl[111] wl[112] wl[113] wl[114] wl[115]
+ wl[116] wl[117] wl[118] wl[119] wl[120] wl[121] wl[122] wl[123] wl[124]
+ wl[125] wl[126] wl[127] wl[128] wl[129] wl[130] wl[131] wl[132] wl[133]
+ wl[134] wl[135] wl[136] wl[137] wl[138] wl[139] wl[140] wl[141] wl[142]
+ wl[143] wl[144] wl[145] wl[146] wl[147] wl[148] wl[149] wl[150] wl[151]
+ wl[152] wl[153] wl[154] wl[155] wl[156] wl[157] wl[158] wl[159] wl[160]
+ wl[161] wl[162] wl[163] wl[164] wl[165] wl[166] wl[167] wl[168] wl[169]
+ wl[170] wl[171] wl[172] wl[173] wl[174] wl[175] wl[176] wl[177] wl[178]
+ wl[179] wl[180] wl[181] wl[182] wl[183] wl[184] wl[185] wl[186] wl[187]
+ wl[188] wl[189] wl[190] wl[191] wl[192] wl[193] wl[194] wl[195] wl[196]
+ wl[197] wl[198] wl[199] wl[200] wl[201] wl[202] wl[203] wl[204] wl[205]
+ wl[206] wl[207] wl[208] wl[209] wl[210] wl[211] wl[212] wl[213] wl[214]
+ wl[215] wl[216] wl[217] wl[218] wl[219] wl[220] wl[221] wl[222] wl[223]
+ wl[224] wl[225] wl[226] wl[227] wl[228] wl[229] wl[230] wl[231] wl[232]
+ wl[233] wl[234] wl[235] wl[236] wl[237] wl[238] wl[239] wl[240] wl[241]
+ wl[242] wl[243] wl[244] wl[245] wl[246] wl[247] wl[248] wl[249] wl[250]
+ wl[251] wl[252] wl[253] wl[254] wl[255] dec_256_out
Xinv_4_1 dec4_b[12] dec4_b[13] dec4_b[14] dec4_b[15] dec4[12] dec4[13]
+ dec4[14] dec4[15] inv_4
Xinv_4_2 dec4_b[8] dec4_b[9] dec4_b[10] dec4_b[11] dec4[8] dec4[9] dec4[10]
+ dec4[11] inv_4
Xinv_4_3 dec4_b[4] dec4_b[5] dec4_b[6] dec4_b[7] dec4[4] dec4[5] dec4[6]
+ dec4[7] inv_4
Xinv_4_4 dec4_b[0] dec4_b[1] dec4_b[2] dec4_b[3] dec4[0] dec4[1] dec4[2]
+ dec4[3] inv_4
Xinv3_16__6 predecB_b[0] predecB_b[1] predecB_b[2] predecB_b[3]
+ predecB_b[4] predecB_b[5] predecB_b[6] predecB_b[7] predecB_b[8]
+ predecB_b[9] predecB_b[10] predecB_b[11] predecB_b[12] predecB_b[13]
+ predecB_b[14] predecB_b[15] predecB[0] predecB[1] predecB[2] predecB[3]
+ predecB[4] predecB[5] predecB[6] predecB[7] predecB[8] predecB[9]
+ predecB[10] predecB[11] predecB[12] predecB[13] predecB[14] predecB[15]
+ inv3_16_predec
Xinv3_16__7 predecA_b[0] predecA_b[1] predecA_b[2] predecA_b[3]
+ predecA_b[4] predecA_b[5] predecA_b[6] predecA_b[7] predecA_b[8]
+ predecA_b[9] predecA_b[10] predecA_b[11] predecA_b[12] predecA_b[13]
+ predecA_b[14] predecA_b[15] predecA[0] predecA[1] predecA[2] predecA[3]
+ predecA[4] predecA[5] predecA[6] predecA[7] predecA[8] predecA[9]
+ predecA[10] predecA[11] predecA[12] predecA[13] predecA[14] predecA[15]
+ inv3_16_predec
Xd4_16_2 clk dec4[8] dec4[9] dec4[10] dec4[11] dec4[12] dec4[13] dec4[14]
+ dec4[15] predecB_b[0] predecB_b[1] predecB_b[2] predecB_b[3] predecB_b[4]
+ predecB_b[5] predecB_b[6] predecB_b[7] predecB_b[8] predecB_b[9]
+ predecB_b[10] predecB_b[11] predecB_b[12] predecB_b[13] predecB_b[14]
+ predecB_b[15] dec4_16
Xd4_16_1 clk dec4[0] dec4[1] dec4[2] dec4[3] dec4[4] dec4[5] dec4[6]
+ dec4[7] predecA_b[0] predecA_b[1] predecA_b[2] predecA_b[3] predecA_b[4]
+ predecA_b[5] predecA_b[6] predecA_b[7] predecA_b[8] predecA_b[9]
+ predecA_b[10] predecA_b[11] predecA_b[12] predecA_b[13] predecA_b[14]
+ predecA_b[15] dec4_16
*input: name=in[7:0], at=0.0, s=(0.08,0.08), c=15;
*output: name=wl[255:0], c=294;
*glbcnst: D<0.3;
*glbcnst: MAXWIDTH =100;
*glbcnst: MINWIDTH = 0.25;
*input: name=clk, at=0.0, s=(0.08,0.08), c=10000;
*glbcnst: MAX_VTH_P =0.4;
*glbcnst: MAX_VTH_N =0.38;
*glbcnst: MIN_VTH_P =0.28;
*glbcnst: MIN_VTH_N =0.22;
*input: name=in_b[7:0], at=0.0, s=(0.08,0.08), c=15;
* .ENDS	$ dec8_256

.GLOBAL gnd vdd

.END
